#include "demo_font.h"

/* Column bitmaps: bit 0 is the top pixel. This small font keeps diagnostics
 * independent of a GUI framework or external font assets. */
static const uint8_t digits[10][5] = {
    {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},
    {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39},
    {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E},
};

static const uint8_t letters[26][5] = {
    {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36},
    {0x3E,0x41,0x41,0x41,0x22}, {0x7F,0x41,0x41,0x22,0x1C},
    {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01},
    {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,0x08,0x08,0x08,0x7F},
    {0x00,0x41,0x7F,0x41,0x00}, {0x20,0x40,0x41,0x3F,0x01},
    {0x7F,0x08,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
    {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F},
    {0x3E,0x41,0x41,0x41,0x3E}, {0x7F,0x09,0x09,0x09,0x06},
    {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7F,0x01,0x01},
    {0x3F,0x40,0x40,0x40,0x3F}, {0x1F,0x20,0x40,0x20,0x1F},
    {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,0x08,0x14,0x63},
    {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43},
};

esp_err_t demo_font_draw(st7789_display_handle_t display, int x, int y,
                         const char *text, unsigned int scale, uint16_t color)
{
    if (!display || !text || scale < 1 || scale > 8 || x < 0 || y < 0) {
        return ESP_ERR_INVALID_ARG;
    }
    const int step = 6 * (int)scale;
    for (; *text; ++text) {
        if (x > st7789_display_width(display) - 5 * (int)scale) {
            break;
        }
        const uint8_t *glyph = NULL;
        if (*text >= '0' && *text <= '9') {
            glyph = digits[*text - '0'];
        } else if (*text >= 'A' && *text <= 'Z') {
            glyph = letters[*text - 'A'];
        }
        if (glyph) {
            for (int col = 0; col < 5; ++col) {
                for (int row = 0; row < 7; ++row) {
                    if ((glyph[col] >> row) & 1u) {
                        esp_err_t ret = st7789_display_fill_rect(display,
                            x + col * (int)scale, y + row * (int)scale,
                            (int)scale, (int)scale, color);
                        if (ret != ESP_OK) {
                            return ret;
                        }
                    }
                }
            }
        }
        x += step;
    }
    return ESP_OK;
}
